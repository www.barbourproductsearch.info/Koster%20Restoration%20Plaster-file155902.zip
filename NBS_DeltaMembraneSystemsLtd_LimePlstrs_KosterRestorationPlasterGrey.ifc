Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-15T11:18:59
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Wall:NBS_DeltaMembraneSystemsLtd_LimePlasters_KosterRestorationPlasterGrey, Basic Wall:NBS_DeltaMembraneSystemsLtd_LimePlasters_KosterRestorationPlasterGrey:222043
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_LimePlasters_KosterRestorationPlasterGrey 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_35_31_64_47: Lime plasters; Color: n/a; Finish: n/a; Material: n/a; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Grey salt and moisture resistant restoration plaster for internal and external use.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster Restoration Plaster Grey; Name: LimePlasters_KosterRestorationPlasterGrey_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_LimePlasters_KosterRestorationPlasterGrey; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/7f57bb79-a9c3-cbab-54a7-8a9dac08a2c8/f57fea50-1822-43e3-8365-cd85ce5d582d; Uniclass2015Code: Pr_35_31_64_47; Uniclass2015Title: Lime plasters; Uniclass2015Version: Products v1.35; Version: 7
Type - NBS_Data - CountryOfProductManufacture: Germany; Colour: Grey; ConsumptionPerLayerApplied: 12 kg/m²/cm; CompressiveStrength: >5.5 N/mm²; FlexuralStrength: >2.5 N/mm²; SettingTime: 3 H; ModulusOfElasticity: >6500 N/mm²; RequiredWater: 2.8–3.3 L/ 25 kg; Density: 1.3 kg/L; Third-partyCertification: CE marked to BS EN 998-1
Classification: Pr_35_31_64_47 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_DeltaMembraneSystemsLtd_LimePlasters_KosterRestorationPlasterGrey, Floor:NBS_DeltaMembraneSystemsLtd_LimePlasters_KosterRestorationPlasterGrey:221893
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_LimePlasters_KosterRestorationPlasterGrey 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_35_31_64_47: Lime plasters; Color: n/a; Finish: n/a; Material: n/a; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Grey salt and moisture resistant restoration plaster for internal and external use.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster Restoration Plaster Grey; Name: LimePlasters_KosterRestorationPlasterGrey_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_LimePlasters_KosterRestorationPlasterGrey; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/7f57bb79-a9c3-cbab-54a7-8a9dac08a2c8/69632bec-c03d-49e3-b75c-ac007e9d2bb9; Uniclass2015Code: Pr_35_31_64_47; Uniclass2015Title: Lime plasters; Uniclass2015Version: Products v1.35; Version: 6
Type - NBS_Data - CountryOfProductManufacture: Germany; Colour: Grey; ConsumptionPerLayerApplied: 12 kg/m²/cm; CompressiveStrength: >5.5 N/mm²; FlexuralStrength: >2.5 N/mm²; SettingTime: 3 H; ModulusOfElasticity: >6500 N/mm²; RequiredWater: 2.8–3.3 L/ 25 kg; Density: 1.3 kg/L; Third-partyCertification: CE marked to BS EN 998-1
Classification: Pr_35_31_64_47 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
